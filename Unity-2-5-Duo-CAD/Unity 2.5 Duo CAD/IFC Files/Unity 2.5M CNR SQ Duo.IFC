Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: Unity 2.5M CNR SQ Duo.IFC
Time: 2020-06-19T01:53:29
Written by: SwIFC
Made in: SolidWorks 2017

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m
